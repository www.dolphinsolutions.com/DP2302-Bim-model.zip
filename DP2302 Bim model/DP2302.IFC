Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2X3
File name: DP2302.IFC
Time: 2020-03-26T09:43:37
Written by: SwIFC
Made in: SolidWorks 2019

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0

# IfcBuildingElementProxy: DP2302
In: Default Storey
Material: Steel
